|Texas Instruments Incorporated
|16 channel retimer with integrated signal conditioning which includes
|an input Continuous-Time Linear Equalizer (CTLE),
|clock and data recovery (CDR)
|and transmit driver on each channel.
| Marketing part#   Voltage Range   Package-type   #pins
| D125DF1610   +2.375 to +2.625   FCBGA   196
[IBIS Ver]   5.1
[File Name]   ds125df1610_rx.ibs
[File Rev]   1.0
[Component]   ds125df1610_rx
[Manufacturer] Texas Instruments
[Disclaimer]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
[Copyright] (C) Copyright 2017 Texas Instruments Incorporated.
   All rights reserved.
[Package]
R_pkg  0.0   NA   NA
L_pkg  0.0   NA   NA
C_pkg  0.0   NA   NA
[Pin]   signal_name   model_name   R_pin L_pin  C_pin
2p   ds125df1610_rx_2p   ds125df1610_rx
2n   ds125df1610_rx_2n   ds125df1610_rx
[Diff_Pin] inv_pin vdiff tdelay_typ tdelay_min tdelay_max
2p   2n   NA   NA   NA   NA
[Model] ds125df1610_rx
Model_type Input
C_comp 0p 0p 0p
Vinh = 0.25
Vinl = -0.25
[Temperature_Range] 25 125 0
[Voltage Range] 1.0 1.0 1.0
[Algorithmic Model]
Executable Windows_cl17.00.50727.1_64 ds125df1610_rx_x64.dll ds125df1610_rx.ami
Executable Windows_cl17.00.50727.1_32 ds125df1610_rx.dll ds125df1610_rx.ami
[End Algorithmic Model]
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| Models and submodels in the file (1): ds125df1610_rx (Input)
