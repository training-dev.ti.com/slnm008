[IBIS Ver]   5.0
[File Name]   rx1.ibs
[File Rev]   1.0
[Component]   Rx1
[Manufacturer] Texas Instruments
[Package]
R_pkg  0.0   NA   NA
L_pkg  0.0   NA   NA
C_pkg  0.0   NA   NA
[Pin]   signal_name   model_name   R_pin L_pin  C_pin
2p   rx1_2p   rx1
2n   rx1_2n   rx1
[Diff_Pin] inv_pin vdiff tdelay_typ tdelay_min tdelay_max
2p   2n   NA   NA   NA   NA
[Model] rx1
Model_type Input
C_comp 0p 0p 0p
Vinh = 0.25
Vinl = -0.25
[Temperature_Range] 25 125 0
[Voltage Range] 1.0 1.0 1.0
[Algorithmic Model]
Executable Windows_cl16.00.30319.01_64 rx1_x64.dll rx1.ami
Executable Windows_cl16.00.30319.01_32 rx1.dll rx1.ami
[End Algorithmic Model]
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| Models and submodels in the file (1): rx1 (Input)
